# Keil uVision project serial.uvproj, settings and files
target serial (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1114/202 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: serial
  c flags: Optim=1
  c include: C:\LPCOpen\software\lpc_core\lpc_chip\chip_11xx
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Startup
    ./: startup_LPC11xx.s system_LPC11xx.c
  group Serial
    ./: main.c Serial.c Retarget.c i2c.c 6050.c
